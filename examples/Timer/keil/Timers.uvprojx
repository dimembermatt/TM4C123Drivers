# Keil uVision project Timers.uvprojx, settings and files
target Timer (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Timer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../../../inc/: startup.s
    ../../../lib/GPIO/: GPIO.c
    ../../../lib/Timer/: Timer.c
    ./: TimerExample.c
    ../../../lib/FaultHandler/: FaultHandler.c
    ../../../lib/PLL/: PLL.c
    ../../../lib/UART/: UART.c
software components: CMSIS:CORE 5.4.0
