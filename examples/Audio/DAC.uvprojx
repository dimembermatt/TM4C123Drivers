# Keil uVision project DAC.uvprojx, settings and files
target Audio (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Audio
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../../inc/: startup.s PLL.c
    ../../lib/GPIO/: GPIO.c
    ./: AudioExample.c Audio.c Song.c
    ../../lib/DAC/: Audio.h DAC.c DAC.h DACSPI.c DACSPI.h Song.h Sound.c Sound.h
    ../../lib/SSI/: SSI.c
    ../../lib/Timers/: Timers.c
software components: CMSIS:CORE 5.0.2
