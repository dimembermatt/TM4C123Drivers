# Keil uVision project Sound.uvprojx, settings and files
target Sound (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sound
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../../inc/: startup.s PLL.c CortexM.c
    ../../lib/DAC/: DAC.c DACSPI.c Sound.c
    ../../lib/Timers/: Timers.c
    ../../lib/DAC/Profiles/: SineProfile.c
    ../../lib/GPIO/: GPIO.c
    ../../lib/SSI/: SSI.c
    ../../lib/Misc/: Misc.c
    ./: SoundExample.c
software components: CMSIS:CORE 5.0.2
