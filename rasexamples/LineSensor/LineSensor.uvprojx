# Keil uVision project LineSensor.uvprojx, settings and files
target GPIO (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../../inc/: startup.s PLL.c
    ../../lib/GPIO/: GPIO.c
    ../../lib/ADC/: ADC.c
    ../../lib/Misc/: Misc.c
    ../../lib/Timers/: Timers.c
    ./: LineSensorExample.c
    ../../raslib/LineSensor/: LineSensor.c
software components: CMSIS:CORE 5.4.0
